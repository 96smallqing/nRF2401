# Keil uVision project STC15NRFre_2.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: STC15NRFre_2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\oled;..\STC15NRFre;.\Time4;.\uart2
  group Source Group 1
    ./: STC15NRFre_2.c
    ./oled/: oled.c
    ./Time4/: T4_time.c
    ./uart2/: delay.c esp8266.c
